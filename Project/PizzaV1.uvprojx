# Keil uVision project PizzaV1.uvprojx, settings and files
target Pizza (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PizzaV1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c misc: --cpp11
  c include: ..\User;..\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ../User/: main.cpp AppConfig.cpp
  group Driver
    ../User/Driver/: Flash.cpp PCUart.cpp MDBUart.cpp ScanQRCodeUart.cpp PositionSwitch.cpp Motor.cpp ElevatorMotor.cpp RotationMotor.cpp CurrentSense.cpp DS18B20.cpp
  group Thread
    ../User/Thread/: MainThread.cpp MessageQueue.cpp Mutex.cpp Thread.cpp DeliveryThread.cpp
  group Message
    ../User/Message/: AsyncMessage.cpp BaseMessage.cpp PCMessage.cpp MDBMessage.cpp ScanQRCodeMessage.cpp
  group Custom
    ../User/Custom/: BaseFormat.cpp BaseOutput.cpp
  group myLib
    ../User/myLib/: ByteArray.cpp Logger.cpp String.cpp
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0
